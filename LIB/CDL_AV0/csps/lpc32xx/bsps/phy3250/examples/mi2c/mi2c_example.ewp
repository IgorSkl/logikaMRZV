# IAR project mi2c_example.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lpc\include; ..\..\..\..\include; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: adc_example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\linker\LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_xRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\linker\LPC3000_xRAM.icf
configuration Release_xRAM_boot_from_NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NAND256
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: ..\linker\LPC3000_xRAM.icf
configuration Release_xRAM_boot_from_NAND512(64M) (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: ..\linker\LPC3000_xRAM.icf
  group (top)
    ../common/: cstartup.s main_iar.c
    ./: mi2c_example.c
    ../: readme.txt
  group BOOT
    ../common/: nand_bootloader.c
  group BSP
    ../../source/: phy3250_board.c phy3250_nand.c
  group Common
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x16.c lpc_rom8x8.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group CSP
    ../../../../source/: lpc32xx_adc_driver.c lpc32xx_clcdc_driver.c lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_hsuart_driver.c lpc32xx_i2c_driver.c lpc32xx_i2s_driver.c lpc32xx_intc_driver.c lpc32xx_kscan_driver.c lpc32xx_mlcnand_driver.c lpc32xx_mstimer_driver.c lpc32xx_mstr_i2c_driver.c lpc32xx_pwm_driver.c lpc32xx_rtc_driver.c lpc32xx_sdcard_driver.c lpc32xx_slcnand_driver.c lpc32xx_spi_driver.c lpc32xx_ssp_driver.c lpc32xx_timer_driver.c lpc32xx_tsc_driver.c lpc32xx_uart_driver.c lpc32xx_vectors.s lpc32xx_wdt_driver.c lpc3xxx_spwm_driver.c
