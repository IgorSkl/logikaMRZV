# IAR project hr1_0100_00_i650.ewp, settings and files
configuration Debug xRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3240 NXP LPC3240
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\NXP\; ..\LIB\include\; ..\inc\; ..\Igor\; ..\mal\; ..\component\; ..\psupervisor\; ..\virtualMenu\; ..\callbackElement\; ..\logictimers\; ..\zonaVRT\; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ICODE_IRAM_DEF
  OBJCOPY.OOCOutputFile: hr1_0100_00_i720.bin
  ILINK.IlinkOutputFile: hr1_0100_00_i720.out
  ILINK.IlinkIcfFile: ..\cfg\LPC3000_xRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: _STATIC_MEMORY_BOOT
  OBJCOPY.OOCOutputFile: hr1_0100_00_i650.bin
  ILINK.IlinkOutputFile: hr1_0100_00_i650.out
  ILINK.IlinkIcfFile: ..\cfg\LPC3000_xFlash.icf
  group (top)
    ../: br_var.c main.c periodOperations.c start_settings.c toSpeedDIS.c toSpeedOptim.c
  group CallBackElement
    ../callbackElement/: callBackElement.c missionCollectionEEPROM1.c missionCollectionEEPROM2.c
  group cfg
    ../cfg/: LPC3000_iRAM.icf LPC3000_iRAM.mac LPC3000_xFlash.icf LPC3000_xRAM-xFlash.mac
  group component
    ../component/: APVComponent.c DZ1Component.c DZ2Component.c DZ3Component.c DZ4Component.c DZ5Component.c DZPacket.c logicAPV.c logicDZ1.c logicDZ2to5.c logicMTZ1.c logicMTZ2to5.c logicNZOP1to2.c logicOF.c logicPF.c logicPRM1.c logicTZNP1to5.c logicUMM.c logicUROV.c logicWL.c MTZ1Component.c MTZ2Component.c MTZ3Component.c MTZ4Component.c MTZ5Component.c MTZPacket.c NZOP1Component.c NZOP2Component.c NZOPPacket.c OFComponent.c PFComponent.c PRM1Component.c TZNP1Component.c TZNP2Component.c TZNP3Component.c TZNP4Component.c TZNP5Component.c TZNPPacket.c UMMComponent.c UROVComponent.c WLComponent.c
  group dataEEPROM
    ../dataEEPROM/: cicloGrammaEEPROM1.c cicloGrammaEEPROM2.c extentiontoEEPROM.c rangirtoEEPROM.c ustavkitoEEPROM.c
  group DCC
    ../DCC/: JLINKDCC_HandleDataAbort.s JLINKDCC_Process.c
  group ici
    ../ici/: AppCn.c CTpu.c cy7.c hu1.c hu1l.c hu2.c hu2l.c hu7.c hu7l.c ici_api.c lpu.c ssp1.c ssp1L.c u3.c u3l.c
  group Igor
    ../Igor/: constants_privat.h diagnostyka.h macroses_privat.h
  group inc
    ../inc/: constants.h functions_external.h functions_global.h header.h hsuart_const.h libraries.h type_definition.h variables_external.h variables_global.h
  group logictimers
    ../logictimers/: FLogTimer.c FLogTimerRES.c ILogTimer.c ILogTimerRES.c logictimers.c
  group NXP/board
    ../NXP/: arm_comm.h board_lowlevel.c cstartup.s
  group NXP/CDL_AV1/csps
    ../LIB/CDL_AV0/csps/lpc32xx/source/: lpcAV1_dma_driver.c lpcAV1_hsuart_driver.c lpcAV1_intc_driver.c lpcAV1_ssp_driver.c lpcAV1_timer_driver.c lpcAV1_uart_driver.c
  group NXP/LPC_CDL/include
    ../LIB/include/: lpc32xx_chip.h lpc32xx_clkpwr.h lpc32xx_clkpwr_driver.h lpc32xx_gpio.h lpc32xx_gpio_driver.h lpc32xx_hstimer.h lpc32xx_hstimer_driver.h lpc32xx_intc.h lpc32xx_intc_driver.h lpc_arm922t_arch.h lpc_arm922t_cp15_driver.h lpc_arm_arch.h lpc_irq_fiq.h lpc_params.h lpc_types.h
  group NXP/LPC_CDL/source
    ../LIB/source/: lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_intc_driver.c lpc32xx_spi_driver.c lpc32xx_uart_driver.c lpc32xx_vectors.s lpc_arm922t_cp15_driver.c partial_vfp.s
  group NXP/MMU
    ../NXP/: arm926ej_cp15_drv.c arm926ej_cp15_drv.h ttbl.c ttbl.h
  group psupervisor
    ../psuperVisor/: psupervisor.c psvisor_help.c
  group SettingIci
    ../SettingIci/: getINTERFACE.c SettingIci_APV.c SettingIci_data.c SettingIci_DZ1.c SettingIci_DZ2to5.c SettingIci_MTZ.c SettingIci_NZOP.c SettingIci_OF.c SettingIci_OFDZ.c SettingIci_OFMTZ.c SettingIci_OFTZNP.c SettingIci_OFUMM.c SettingIci_PRM1.c SettingIci_Rangir.c SettingIci_RangirAPV.c SettingIci_RangirDZ.c SettingIci_RangirMTZ.c SettingIci_RangirNZOP.c SettingIci_RangirOF.c SettingIci_RangirOT.c SettingIci_RangirPRM1.c SettingIci_RangirTZNP.c SettingIci_RangirUMM.c SettingIci_RangirUROV.c SettingIci_TZNP.c SettingIci_UMM.c SettingIci_UROV.c translateI.c
  group virtualMenu
    ../virtualMenu/: extmanager.c rangmanager.c ResetSystemMenu.c systemMenu.c TxtStream.c ustmanager.c ViewMenuCnf.c viewMenuList.c ViewMenuRang.c ViewMenuReg.c viewMenuSub.c ViewMenuTip.c ViewMenuWideLog.c ViewRepozit.c ViewRepozitWL.c widelogmanager.c
  group zonaVRT
    ../zonaVRT/: isNewZonaMethodVRT.c isZonaTrianMethodVRT.c toSpeedZonaVRT.c zonaVRT.h
